File: hardware/monitoramento_agua/monitoramento_agua.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Add mcu schematic
Other:
- added sheet MCU (atmega328p_sch.kicad_sch)
